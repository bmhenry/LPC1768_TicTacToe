# Keil uVision project rtx_blinky_ind.uvprojx, settings and files
target Flash (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtx_blinky_ind
  c flags: Optim=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: Blinky.c
    ./src/: GLCD_Modified.c ttt.c
  group Documentation
    ./: Abstract.txt
  group Board Support
    ./src/: led_mcb1700.c
  group CMSIS
    ./src/: rtx_conf_cm.c
    ./lib/: RTX_CM3.lib
  group Device
    ./startup/: system_lpc17xx.c startup_lpc17xx.s
    ./src/: gpio_lpc17xx.c pin_lpc17xx.c
